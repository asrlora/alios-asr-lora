# Keil uVision project cm4.uvprojx, settings and files
target mqttapp (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CY8C6347BZI-BLD53_Pack:CortexM4 Cypress
  pack: Cypress.Pack.5.2.4
  cpu: IRAM(0x8000000,0x48000) IROM(0x10000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: cm4
  AfterMake: $KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\postbuildCortexM4.bat "#L" -p "$P" "cmsis" "$KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\win\elf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MQTT_PRESS_TEST
  c include: ..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\drivers\peripheral;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\cmsis\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\ip;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\psoc63\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\middleware;..\..\..\..\platform\mcu\cy8c6347\drivers;..\..\..\..\board\cy8ckit-062
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x8000000 size 0x48000
  scatter file: ..\..\..\..\platform\mcu\cy8c6347\drivers\linker_file\cy8c6xx7_cm4_dual.scat
  group activation
    ../../../.././framework/activation/./Cortex-M4/KEIL/: activation.a
  group alicrypto
    ../../../.././security/alicrypto/./libalicrypto/: ali_crypto.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/asym/: rsa.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/cipher/: aes.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/hash/: hash.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/mac/: hmac.c
    ../../../.././security/alicrypto/./libalicrypto/sw/: ali_crypto_rand.c
    ../../../.././security/alicrypto/./libalicrypto/test/: ali_crypto_test.c ali_crypto_test_aes.c ali_crypto_test_comm.c ali_crypto_test_hash.c ali_crypto_test_hmac.c ali_crypto_test_rand.c ali_crypto_test_rsa.c
    ../../../.././security/alicrypto/./mbedtls/library/: aes.c asn1parse.c bignum.c hash_wrap.c hmac.c mbedtls_alt.c md5.c oid.c rsa.c sha1.c sha256.c threading.c
  group atparser
    ../../../.././framework/atparser/: atparser.c
  group board_b_l475e
    ../../../../board/cy8ckit-062/: board.c
  group base64
    ../../../.././utility/base64/: base64.c
  group cjson
    ../../../.././utility/cjson/: cJSON.c cJSON_Utils.c
  group cli
    ../../../.././tools/cli/: cli.c dumpsys.c
  group mqtt
    ../../../.././framework/connectivity/mqtt/: mqtt_client.c mqtt_instance.c
  group MQTTPacket
    ../../../.././framework/connectivity/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group digest_algorithm
    ../../../.././utility/digest_algorithm/: CheckSumUtils.c crc.c digest_algorithm.c md5.c
  group fota
    ../../../.././framework/fota/: ota_service.c ota_update_manifest.c ota_util.c ota_version.c
  group fota_download
    ../../../.././framework/fota/download/: download_common.c
  group download_http
    ../../../.././framework/fota/download/http/: ota_download.c
  group socket_stand
    ../../../.././framework/fota/download/http/socket/stand/: ota_socket.c
  group fota_platform
    ../../../.././framework/fota/platform/: ota_platform_os.c
  group fota_mqtt_transport
    ../../../.././framework/fota/platform/mqtt/: ota_transport.c version_report.c
  group framework
    ../../../../././framework/common/: main.c version.c
  group hal
    ../../../.././kernel/hal/: ota.c wifi.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c
  group log
    ../../../.././utility/log/: log.c
  group mbedtls
    ../../../.././security/mbedtls/src/: aes.c aesni.c arc4.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c mbedtls_alt.c mbedtls_net.c mbedtls_ssl.c md.c md2.c md4.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../.././security/mbedtls/lib/Cortex-M4/KEIL/: libmbedtls.lib
  group kv
    ../../../.././kernel/modules/fs/kv/: kvmgr.c
  group mqttapp
    ../../../.././example/mqttapp/: mqtt-example.c
    ../../../../example/rhinorun/: ymodem.c rhino_p6.c
  group netmgr
    ../../../.././framework/netmgr/: netmgr.c
  group armv7m
    ../../../../././platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
  group stm32l475
    ../../../../platform/mcu/cy8c6347/aos/: soc_impl.c trace_impl.c
    ../../../../platform/mcu/cy8c6347/drivers/: cy_ipc_config.c system_psoc63_cm4.c
    ../../../../platform/mcu/cy8c6347/drivers/startup/: startup_psoc63_cm4.s
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/: cyfitter_sysint_cfg.c cymetadata.c UART1.c UART5.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/flash/: cy_flash.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/gpio/: cy_gpio.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/ipc/: cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/scb/: cy_scb_common.c cy_scb_ezi2c.c cy_scb_i2c.c cy_scb_spi.c cy_scb_uart.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysclk/: cy_sysclk.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysint/: cy_sysint.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/: cy_syslib.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syspm/: cy_syspm.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/systick/: cy_systick.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/wdt/: cy_wdt.c
    ../../../../platform/mcu/cy8c6347/hal/: flash_port.c hw.c ota_port.c uart_port.c
    ../../../../platform/mcu/cy8c6347/runapp/: aos.c
  group iotkit
    ../../../.././framework/protocol/linkkit/iotkit/base/log/LITE-log/: lite-log.c
    ../../../.././framework/protocol/linkkit/iotkit/base/utils//digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../../../.././framework/protocol/linkkit/iotkit/base/utils//misc/: utils_httpc.c utils_list.c utils_net.c utils_timer.c work_queue.c
    ../../../.././framework/protocol/linkkit/iotkit/base/utils/LITE-utils/src/: json_parser.c json_token.c mem_stats.c string_utils.c
    ../../../.././framework/protocol/linkkit/iotkit/hal-impl/rhino/: HAL_OS_rhino.c HAL_PRODUCT_rhino.c HAL_TCP_rhino.c HAL_UDP_rhino.c
    ../../../.././framework/protocol/linkkit/iotkit/hal-impl/tls/mbedtls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
    ../../../.././framework/protocol/linkkit/iotkit/iotkit-system/src/: ca.c class_interface.c device.c guider.c id2_guider.c report.c sdk-impl.c
    ../../../.././framework/protocol/linkkit/iotkit/layers/config/src/: dev_conf.c
  group rhino
    ../../../.././kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group sal
    ../../../.././device/sal/: ip4_addr.c sal.c sal_arch.c sal_device.c sal_err.c sal_sockets.c
  group device_sal_mk3060
    ../../../.././device/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
  group vcall
    ../../../.././kernel/vcall/aos/: aos_rhino.c
  group vfs
    ../../../.././kernel/vfs/: device.c select.c vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group yloop
    ../../../.././kernel/yloop/: local_event.c yloop.c
